RUST_TARGETS_DIR = "${RECIPE_SYSROOT_NATIVE}/usr/lib/rustlib"
RUST_HOST_SYS:task-compile = "${HOST_SYS}"
